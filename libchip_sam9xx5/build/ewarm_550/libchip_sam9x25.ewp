# IAR project libchip_sam9x25.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: SAM9X25 Atmel SAM9X25
  ICCARM.CCDefines: sam9x25; TRACE_LEVEL=3
  ICCARM.CCIncludePath2: ../../; ../../cp15; ../../../usb/include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: libsam9x25.out
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: SAM9X25 Atmel SAM9G25
  ICCARM.CCDefines: NDEBUG; sam9x25
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: libchip_sam9x25.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../: chip.h
  group cp15
    ../../cp15/: core.h cp15.c cp15.h cp15_asm_iar.s
  group include
    ../../include/: acc.h adc.h can.h async.h dacc.h dmac.h efc.h emac.h hsmci.h irq.h mmu.h pio.h pio_capture.h pio_it.h pit.h pmc.h pwmc.h rstc.h rtc.h rtt.h SAM9X25.h spi.h spi_pdc.h ssc.h tc.h trace.h twi.h twid.h usart.h wdt.h
  group source
    ../../source/: adc.c aic.c async.c can.c dmac.c emac.c hsmci.c mmu.c pio.c pio_it.c pit.c pmc.c pwmc.c rstc.c rtc.c spi.c ssc.c tc.c twi.c twid.c usart.c USBD_HAL.c wdt.c
