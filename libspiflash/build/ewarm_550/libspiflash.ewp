# IAR project libspiflash.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: sam9g25 Atmel sam9g25
  ICCARM.CCDefines: sam9g25; TRACE_LEVEL=3
  ICCARM.CCIncludePath2: ../../../libboard_sam9xx5-ek; ../../; ../../../libchip_sam9xx5/; ../../../libspiflash/
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: sam9g25
  ILINK.IlinkOutputFile: libspiflash.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; sam9g25
  ICCARM.CCOptLevel: 3
  group (top)
    ../../: board.h
  group include
    ../../include/: at25_spi.h at25d.h at45_spi.h at45d.h spi_dma.h
  group source
    ../../source/: at25_spi.c at25d.c at45_spi.c at45d.c spid_dma.c
