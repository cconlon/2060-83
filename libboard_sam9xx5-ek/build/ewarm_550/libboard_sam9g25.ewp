# IAR project libboard_sam9g25.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: sam9g25 Atmel sam9g25
  ICCARM.CCDefines: sam9g25; TRACE_LEVEL=3
  ICCARM.CCIncludePath2: ../../; ../../../libchip_sam9xx5/; ../../../libsdmmc/
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: sam9g25
  ILINK.IlinkOutputFile: libsam9g25.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; sam9g25
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: libboard_sam9g25-ek.out
  group (top)
    ../../: board.h
  group include
    ../../include/: bitbanding.h bmp.h board_lowlevel.h board_memories.h clock.h dbg_util.h dmad.h emacd.h hamming.h led.h macb.h math.h mcid.h mii.h rand.h omnivision_ov2640.h uart_console.h wav.h wm8731.h
    ../../source/: qt1070.h
  group source
    ../../source/: bmp.c board_cstartup_iar.s board_lowlevel.c board_memories.c clock.c dbg_util.c dbgu_console.c dma_hardware_interface.c dmad.c emacd.c hamming.c led.c macb.c math.c mcid_dma.c omnivision_ov2640.c qt1070.c rand.c timetick.c trace.c wav.c wm8731.c
