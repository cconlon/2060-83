# IAR project libboard_sam9x35.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM9X35 Atmel SAM9X35
  ICCARM.CCDefines: sam9x35; TRACE_LEVEL=6
  ICCARM.CCIncludePath2: ../../; ../../../libchip_sam9xx5/; ../../../libsdmmc/
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: sam9x35
  ILINK.IlinkOutputFile: libsam9x35.out
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; sam9x35
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: libboard_sam9x35-ek.out
  group (top)
    ../../: board.h
  group include
    ../../include/: bitbanding.h bmp.h board_lowlevel.h board_memories.h cand.h clock.h dbg_util.h dmad.h emacd.h hamming.h lcd_color.h lcd_font.h lcd_font10x14.h lcdd.h led.h macb.h math.h mcid.h mii.h qt1070.h rand.h tsd.h tsd_com.h uart_console.h wav.h wm8731.h
  group source
    ../../source/: bmp.c board_lowlevel.c board_memories.c cand.c clock.c dbg_util.c dbgu_console.c dma_hardware_interface.c dmad.c emacd.c hamming.c lcd_draw.c lcd_font.c lcd_font10x14.c lcdd.c led.c macb.c math.c mcid_dma.c qt1070.c rand.c timetick.c trace.c tsd_com.c tsd_tsadc.c wav.c wm8731.c
