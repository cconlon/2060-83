# IAR project libnandflash.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: sam9g25 Atmel sam9g25
  ICCARM.CCDefines: sam9g25; TRACE_LEVEL=1
  ICCARM.CCIncludePath2: ../../../libboard_sam9xx5-ek; ../../; ../../../libchip_sam9xx5/; ../../../libnandflash/; ../../../libpmecc/
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  AARM.ADefines: sam9g25
  ILINK.IlinkOutputFile: libnandflash.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; sam9g25
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group (top)
    ../../: board.h
  group include
    ../../include/: EccNandFlash..h NandCommon.h NandFlashDma..h NandFlashModel.h NandFlashModelList.h NandFlashOnFi.h NandSpareScheme.h RawNandFlash.h SkipBlockNandFlash.h
  group source
    ../../source/: EccNandFlash.c NandFlashDma.c NandFlashModel.c NandFlashModelList.c NandFlashOnFi.c NandSpareScheme.c RawNandFlash.c SkipBlockNandFlash.c
