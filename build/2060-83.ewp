# IAR project 2060-83.ewp, settings and files
configuration sram (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: sam9x35; sram; TRACE_LEVEL=4
  ICCARM.CCIncludePath2: ../libboard_sam9xx5-ek/; ../libchip_sam9xx5/; ../BSP/; ../; ../uCOS-II/Ports/ARM/Generic/IAR/; ../ucos-ii/source/; ../uC-CPU/; ../uC-CPU/ARM/IAR/; ../uC-LIB/
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: sam9x35; sram; __ASSEMBLY__
  OBJCOPY.OOCOutputFile: sram.bin
  ILINK.IlinkOutputFile: sram.out
  ILINK.IlinkIcfFile: C:\Users\lasserk\Documents\IAR Embedded Workbench\arm\examples\Atmel\sam9x35-ek\libraries\libboard_sam9xx5-ek\resources\ewarm\sam9x35\sram.icf
  ILINK.IlinkProgramEntryLabel: resetHandler
configuration ddram (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: SAM9X35 Atmel SAM9X35
  ICCARM.CCDefines: APP_CFG_DDRAM_EN; sam9x35; TRACE_LEVEL=4
  ICCARM.CCIncludePath2: ../main/; ../libboard_sam9xx5-ek/; ../libchip_sam9xx5/; ../BSP/; ../uCOS-II/Ports/ARM/CSP/; ../uCOS-II/Ports/ARM/Generic/IAR/; ../uCOS-II/Ports/ARM/CSP/Atmel/AT91SAM9xxx/; ../ucos-ii/source/; ../uC-CSP/; ../uC-CSP/Atmel/AT91SAM9X35/; ../uC-CPU/; ../uC-CPU/ARM/IAR/; ../uC-LIB/; ../uC-TCPIP/Source/; ../uC-TCPIP/NIC/ETHER/PHY/; ../uC-TCPIP/OS/uCOS-II/; ../uC-TCPIP/IF/; ../uC-TCPIP/IF/Ether/
  AARM.ADefines: sam9x35; ddram; __ASSEMBLY__
  AARM.AUserIncludes: ..\
  OBJCOPY.OOCOutputFile: 2060-83.bin
  ILINK.IlinkOutputFile: ddram.out
  ILINK.IlinkIcfFile: ..\BSP\sam9xx5-ek-ddram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group BSP
    ../BSP/: bsp.c bsp.h cpu_bsp.c cstartup.s
  group documentation
    $EW_DIR$/arm/examples/Atmel/: flashloaders.html
    $EW_DIR$/arm/examples/Atmel/sam9xx5/sam9x35-ek/documentation/html/: getting-started.html
  group libraries
    ../libboard_sam9xx5-ek/lib/: libboard_sam9x35_ek_ewarm_dbg.a
    ../libchip_sam9xx5/lib/: libchip_sam9x35_ewarm_dbg.a
  group main
    ../main/: app_cfg.h app_hooks.c includes.h main.c net_bsp.c net_bsp.h net_cfg.h netservices.c netservices.h os_cfg.h
  group main/83
    ../main/83/: command.c command.h common.c common.h define2060.h globe83param.c interface.c interface.h main83.c main83.h mainInterupt.c netio.c netio.h transfer.c transfer.h
  group main/simudata
    ../main/simudata/: simudata.c simudata.h
  group resources
    ../libboard_sam9xx5-ek/resources/ewarm/sam9x35/: ddram.icf sram.icf
  group uC-CPU
    ../uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group uC-CPU/ARM/IAR
    ../uC-CPU/ARM/IAR/: cpu.h cpu_a.s
  group uC-CSP
    ../uC-CSP/: csp.c csp.h csp_types.h
  group uC-CSP/Atmel
    ../uC-CSP/Atmel/AT91SAM9X35/: csp_dev.h csp_gpio.c csp_grp.h csp_int.c csp_pm.c csp_tmr.c
  group uC-LIB
    ../uC-LIB/: lib_def.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uC-LIB/Ports/ARM/IAR
    ../uC-LIB/Ports/ARM/IAR/: lib_mem_a.asm
  group uC-TCPIP/IF
    ../uC-TCPIP/IF/: net_if_pkt.c net_if_pkt.h
  group uC-TCPIP/IF/Ether
    ../uC-TCPIP/IF/Ether/: net_if.c net_if.h
  group uC-TCPIP/NIC/ETHER/PHY
    ../uC-TCPIP/NIC/ETHER/PHY/: net_nic.c net_nic.h
  group uC-TCPIP/OS/uCOS-II
    ../uC-TCPIP/OS/uCOS-II/: net_os.c net_os.h
  group uC-TCPIP/Ports/ARM/IAR
    ../uC-TCPIP/Ports/ARM/IAR/: net_util_a.asm
  group uC-TCPIP/Source
    ../uC-TCPIP/Source/: net.c net.h net_arp.c net_arp.h net_ascii.c net_ascii.h net_bsd.c net_bsd.h net_buf.c net_buf.h net_cfg_net.h net_conn.c net_conn.h net_ctr.c net_ctr.h net_dbg.c net_dbg.h net_def.h net_err.c net_err.h net_icmp.c net_icmp.h net_ip.c net_ip.h net_sock.c net_sock.h net_stat.c net_stat.h net_tcp.c net_tcp.h net_tmr.c net_tmr.h net_type.h net_udp.c net_udp.h net_util.c net_util.h
  group uCOS-II/Ports/ARM/Generic/IAR
    ../uCOS-II/Ports/ARM/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c os_dcc.c
  group uCOS-II/Ports/CSP
    ../uCOS-II/Ports/ARM/CSP/: os_csp.h os_csp_AT91SAM9X35.c
  group uCOS-II/Source
    ../uCOS-II/Source/: os_cfg_r.h os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
