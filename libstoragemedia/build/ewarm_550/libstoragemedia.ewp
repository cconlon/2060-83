# IAR project libstoragemedia.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: sam9g25 Atmel sam9g25
  ICCARM.CCDefines: sam9g25; TRACE_LEVEL=4
  ICCARM.CCIncludePath2: ../../../libboard_sam9xx5-ek; ../../; ../../../libchip_sam9xx5/; ../../../libstoragemedia/; ../../../libstoragemedia/include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: sam9g25
  ILINK.IlinkOutputFile: libstoragemedia.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; sam9g25
  ICCARM.CCOptLevel: 3
  group (top)
    ../../: libstoragemedia.h
  group include
    ../../include/: media.h MedRamDisk.h
  group source
    ../../source/: media.c MEDRamDisk.c
